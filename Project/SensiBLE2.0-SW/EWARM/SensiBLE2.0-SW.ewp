# IAR project SensiBLE2.0-SW.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_ASSERT; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SENSIBLE_2_0; IKS01A1
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\Drivers\BSP\STEVAL-BLUEMIC1; ..\..\..\Middlewares\ST\BlueNRG-1_BlueVoice_Library\Inc; ..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\Library\CMSIS\Include; ..\..\..\Library\hal\inc; ..\..\..\Library\Bluetooth_LE\inc; ..\..\..\Drivers\BSP\Components\veml6075; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\Drivers\BSP\Sensible20; ..\..\..\Library\Bluetooth_LE\OTA\inc; ..\..\..\Drivers\BSP\Components\at25xe041b; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensiBLE-2.0-revC1-OTA.bin
  ILINK.IlinkOutputFile: SensiBLE2.0-SW.out
  ILINK.IlinkConfigDefines: USE_OTA=1
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components/APDS9250
    ../../../Drivers/BSP/Components/apds9250/: APDS9250_LIGHT_driver.c APDS9250_LIGHT_driver.h APDS9250_LIGHT_driver_HL.c APDS9250_LIGHT_driver_HL.h
    ../../../Drivers/BSP/STEVAL-BLUEMIC1/: steval_bluemic1_lux_apds9250.c
  group Drivers/BSP/Components/at25xe041b
    ../../../Drivers/BSP/Components/at25xe041b/: AT25XE041B_Driver.c AT25XE041B_Driver.h
  group Drivers/BSP/Components/Common
    ../../../Drivers/BSP/Components/Common/: accelerometer.h component.h humidity.h light.h magnetometer.h pressure.h sensor.h temperature.h ultraviolet.h
  group Drivers/BSP/Components/hts221
    ../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver.h HTS221_Driver_HL.c HTS221_Driver_HL.h
  group Drivers/BSP/Components/lis2dw12
    ../../../Drivers/BSP/Components/lis2dw12/: LIS2DW12_ACC_driver.c LIS2DW12_ACC_driver_HL.c
  group Drivers/BSP/Components/lis2mdl
    ../../../Drivers/BSP/Components/lis2mdl/: LIS2MDL_MAG_driver.c LIS2MDL_MAG_driver.h LIS2MDL_MAG_driver_HL.c LIS2MDL_MAG_driver_HL.h
  group Drivers/BSP/Components/lps25hb
    ../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver.h LPS25HB_Driver_HL.c LPS25HB_Driver_HL.h
  group Drivers/BSP/Components/veml6075
    ../../../Drivers/BSP/Components/veml6075/: VEML6075_Driver.c VEML6075_Driver.h VEML6075_Driver_HL.c VEML6075_Driver_HL.h
  group Drivers/BSP/SensiBLE-20
    ../../../Drivers/BSP/Sensible20/: sensible20_accelero.c sensible20_bat.c sensible20_bat.h sensible20_compass.c sensible20_compass.h sensible20_led.c sensible20_led.h sensible20_magneto.c sensible20_port_exp.c sensible20_port_exp.h sensible20_spi.c sensible20_spi.h sensible20_steps.c sensible20_steps.h
  group Drivers/BSP/STEVAL-BLUEMIC1
    ../../../Drivers/BSP/STEVAL-BLUEMIC1/: steval_bluemic1.c steval_bluemic1_audio_in.c steval_bluemic1_humidity.c steval_bluemic1_pressure.c steval_bluemic1_temperature.c steval_bluemic1_uv.c
  group Library/BlueNRG1_Drivers
    ../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c misc.c
  group Library/hal
    ../../../Library/hal/src/: clock.c osal.c sleep.c
  group Library/OTA/inc
    ../../../Library/Bluetooth_LE/OTA/inc/: OTA.h
  group Library/OTA/src
    ../../../Library/Bluetooth_LE/OTA/src/: OTA.c
  group Library/Stack
    ../../../Library/Bluetooth_LE/library/: bluenrg1_stack_lib.a
  group Middlewares/BlueNRG-1_BlueVoice_Lib
    ../../../Middlewares/ST/BlueNRG-1_BlueVoice_Library/Lib/: bluevoiceADPCM_BNRG1_100_IAR.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Inc/: motion_mc_cm0p.h
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC110_CM0P_IAR8_ot.a
  group Startup
    ../../../Library/hal/src/: context_switch.s
    ../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../src/: acceleroSamplesProcessing.c BlueNRG1_it.c bluevoice_app.c HWAdvanceFeatures.c inertial_app.c main.c peripheral_mngr_app.c sensible_sensors.c sensible_services.c
