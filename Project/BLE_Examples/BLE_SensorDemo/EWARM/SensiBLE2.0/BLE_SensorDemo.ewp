# IAR project BLE_SensorDemo.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SensorDemo.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo.out
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LowerApp_OTA (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BLUENRG1_DEVICE; _DEBUG=1; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; IKS01A1; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SENSIBLE_2_0; SENSOR_EMULATION=1; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_OTA_LOWER_APPLICATION=1; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\at25xe041b; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\..\Drivers\BSP\Components\veml6075; ..\..\..\..\..\Drivers\BSP\STEVAL-BLUEMIC1; ..\..\..\..\..\Drivers\BSP\Sensible20; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-1_BlueVoice_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MotionMC_Library_2\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MotionMC_Library_2\Lib; ..\..\inc
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_LowerApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_LowerApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_LowerApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_LOWER_APPLICATION=1
configuration HigherApp_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_OTA_HIGHER_APPLICATION=1; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_HigherApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_HigherApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_HigherApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_HIGHER_APPLICATION=1
configuration Use_OTA_ServiceManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_Use_OTA_ServiceManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_SensorDemo_Use_OTA_ServiceManager.bin"
  ILINK.IlinkOutputFile: BLE_SensorDemo_Use_OTA_ServiceManager.out
  ILINK.IlinkConfigDefines: ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  group Drivers/BSP/Components/at25xe041b
    ../../../../../Drivers/BSP/Components/at25xe041b/: AT25XE041B_Driver.c AT25XE041B_Driver.h
  group Drivers/BSP/Components/Common
    ../../../../../Drivers/BSP/Components/Common/: accelerometer.h component.h humidity.h light.h magnetometer.h pressure.h sensor.h temperature.h ultraviolet.h
  group Drivers/BSP/Components/hts221
    ../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver.h HTS221_Driver_HL.c HTS221_Driver_HL.h
  group Drivers/BSP/Components/lis2dw12
    ../../../../../Drivers/BSP/Components/lis2dw12/: LIS2DW12_ACC_driver.c LIS2DW12_ACC_driver.h LIS2DW12_ACC_driver_HL.c LIS2DW12_ACC_driver_HL.h
  group Drivers/BSP/Components/lis2mdl
    ../../../../../Drivers/BSP/Components/lis2mdl/: LIS2MDL_MAG_driver.c LIS2MDL_MAG_driver.h LIS2MDL_MAG_driver_HL.c LIS2MDL_MAG_driver_HL.h
  group Drivers/BSP/Components/lps25hb
    ../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver.h LPS25HB_Driver_HL.c LPS25HB_Driver_HL.h
  group Drivers/BSP/Components/veml6075
    ../../../../../Drivers/BSP/Components/veml6075/: VEML6075_Driver.c VEML6075_Driver.h VEML6075_Driver_HL.c VEML6075_Driver_HL.h
  group Drivers/BSP/Sensible20
    ../../../../../Drivers/BSP/Sensible20/: sensible20_accelero.c sensible20_accelero.h sensible20_bat.c sensible20_bat.h sensible20_compass.c sensible20_compass.h sensible20_led.c sensible20_led.h sensible20_magneto.c sensible20_magneto.h sensible20_port_exp.c sensible20_port_exp.h sensible20_spi.c sensible20_spi.h sensible20_steps.c sensible20_steps.h
  group Drivers/BSP/STEVAL-BLUEMIC1
    ../../../../../Drivers/BSP/STEVAL-BLUEMIC1/: steval_bluemic1.c steval_bluemic1.h steval_bluemic1_audio_in.c steval_bluemic1_audio_in.h steval_bluemic1_humidity.c steval_bluemic1_humidity.h steval_bluemic1_lux.h steval_bluemic1_lux_apds9250.c steval_bluemic1_pressure.c steval_bluemic1_pressure.h steval_bluemic1_temperature.c steval_bluemic1_temperature.h steval_bluemic1_uv.c steval_bluemic1_uv.h
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Middlewares/BlueNRG-1_BlueVoice_Library
    ../../../../../Middlewares/ST/BlueNRG-1_BlueVoice_Library/Inc/: bluevoice_adpcm_bnrg1.h
    ../../../../../Middlewares/ST/BlueNRG-1_BlueVoice_Library/Lib/: bluevoiceADPCM_BNRG1_100_IAR.a
  group Middlewares/STM32_MotionMC_Library_2
    ../../../../../Middlewares/ST/STM32_MotionMC_Library_2/Inc/: motion_mc_cm0p.h
    ../../../../../Middlewares/ST/STM32_MotionMC_Library_2/Lib/: MotionMC_CM0P_wc32_ot.a
  group OTA
    ../../../../../Library/BLE_Application/OTA/src/: OTA.c
    ../../../../../Library/BLE_Application/OTA/inc/: OTA.h
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: LPS25HB.c LSM6DS3.c SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: acceleroSamplesProcessing.c BlueNRG1_it.c bluevoice_app.c debug_print.c HWAdvanceFeatures.c inertial_app.c main.c peripheral_mngr_app.c sensible_sensors.c sensible_services.c
